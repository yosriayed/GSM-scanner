<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>GSM_reciever</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>AGCH</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>BCCH</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>CCCH</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>CHANNEL_UNKNOWN</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>OSR</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>PCH</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>RACH</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>SACCH</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>0x80</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>SDCCH</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>f_1800_b</value></param>
<param><key>value</key><value>1805.2e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>f_1800_e</value></param>
<param><key>value</key><value>1879.8e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>f_900_b</value></param>
<param><key>value</key><value>921.2e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>f_900_e</value></param>
<param><key>value</key><value>959.8e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>f_symb</value></param>
<param><key>value</key><value>1625000.0/6.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>f_symb*4</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>host</key><value>127.0.0.1</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>4729</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_CLIENT"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fc</value></param>
<param><key>label</key><value>fc</value></param>
<param><key>short_id</key><value>f</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>927.2e6</value></param>
</block>
<block>
<key>gsm_clock_offset_control</key>
<param><key>id</key><value>gsm_clock_offset_control_0</value></param>
<param><key>fc</key><value>fc</value></param>
</block>
<block>
<key>gsm_control_channels_decoder</key>
<param><key>id</key><value>gsm_control_channels_decoder_0</value></param>
</block>
<block>
<key>gsm_control_channels_decoder</key>
<param><key>id</key><value>gsm_control_channels_decoder_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>gsm_control_channels_decoder</key>
<param><key>id</key><value>gsm_control_channels_decoder_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>gsm_control_channels_decoder</key>
<param><key>id</key><value>gsm_control_channels_decoder_0_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>gsm_control_channels_decoder</key>
<param><key>id</key><value>gsm_control_channels_decoder_0_0_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>gsm_control_channels_decoder</key>
<param><key>id</key><value>gsm_control_channels_decoder_0_0_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>gsm_control_channels_decoder</key>
<param><key>id</key><value>gsm_control_channels_decoder_0_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>gsm_control_channels_decoder</key>
<param><key>id</key><value>gsm_control_channels_decoder_0_0_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>gsm_decryption</key>
<param><key>id</key><value>gsm_decryption_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>k_c</key><value>[]</value></param>
</block>
<block>
<key>gsm_decryption</key>
<param><key>id</key><value>gsm_decryption_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>k_c</key><value>[]</value></param>
</block>
<block>
<key>gsm_decryption</key>
<param><key>id</key><value>gsm_decryption_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>k_c</key><value>[]</value></param>
</block>
<block>
<key>gsm_decryption</key>
<param><key>id</key><value>gsm_decryption_0_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>k_c</key><value>[]</value></param>
</block>
<block>
<key>gsm_decryption</key>
<param><key>id</key><value>gsm_decryption_0_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>k_c</key><value>[]</value></param>
</block>
<block>
<key>gsm_decryption</key>
<param><key>id</key><value>gsm_decryption_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>k_c</key><value>[]</value></param>
</block>
<block>
<key>gsm_decryption</key>
<param><key>id</key><value>gsm_decryption_0_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>k_c</key><value>[]</value></param>
</block>
<block>
<key>gsm_input</key>
<param><key>id</key><value>gsm_input_0</value></param>
<param><key>osr</key><value>4</value></param>
<param><key>ppm</key><value>0</value></param>
<param><key>samp_rate_in</key><value>samp_rate</value></param>
</block>
<block>
<key>gsm_receiver</key>
<param><key>id</key><value>gsm_receiver_0</value></param>
<param><key>osr</key><value>4</value></param>
</block>
<block>
<key>gsm_universal_ctrl_chans_demapper</key>
<param><key>id</key><value>gsm_universal_ctrl_chans_demapper_0</value></param>
<param><key>channel_types</key><value>[BCCH,CCCH,CCCH,CCCH,CCCH,CCCH,CCCH,CCCH,CCCH,CCCH]</value></param>
<param><key>starts_fn_mod51</key><value>[2,6,12,16,22,26,32,36,42,46]</value></param>
</block>
<block>
<key>gsm_universal_ctrl_chans_demapper</key>
<param><key>id</key><value>gsm_universal_ctrl_chans_demapper_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>channel_types</key><value>[SDCCH, SDCCH, SDCCH, SDCCH, SDCCH, SDCCH, SDCCH, SDCCH,SACCH,SACCH,SACCH,SACCH]</value></param>
<param><key>starts_fn_mod51</key><value>[0,4,8,12,16,20,24,28,32,36,40,44]</value></param>
<param><key>timeslot_nr</key><value>1</value></param>
</block>
<block>
<key>gsm_universal_ctrl_chans_demapper</key>
<param><key>id</key><value>gsm_universal_ctrl_chans_demapper_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>channel_types</key><value>[SDCCH, SDCCH, SDCCH, SDCCH, SDCCH, SDCCH, SDCCH, SDCCH,SACCH,SACCH,SACCH,SACCH]</value></param>
<param><key>starts_fn_mod51</key><value>[0,4,8,12,16,20,24,28]</value></param>
<param><key>timeslot_nr</key><value>2</value></param>
</block>
<block>
<key>gsm_universal_ctrl_chans_demapper</key>
<param><key>id</key><value>gsm_universal_ctrl_chans_demapper_0_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>channel_types</key><value>[SDCCH, SDCCH, SDCCH, SDCCH, SDCCH, SDCCH, SDCCH, SDCCH,SACCH,SACCH,SACCH,SACCH]</value></param>
<param><key>starts_fn_mod51</key><value>[0,4,8,12,16,20,24,28]</value></param>
<param><key>timeslot_nr</key><value>4</value></param>
</block>
<block>
<key>gsm_universal_ctrl_chans_demapper</key>
<param><key>id</key><value>gsm_universal_ctrl_chans_demapper_0_0_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>channel_types</key><value>[SDCCH, SDCCH, SDCCH, SDCCH, SDCCH, SDCCH, SDCCH, SDCCH,SACCH,SACCH,SACCH,SACCH]</value></param>
<param><key>starts_fn_mod51</key><value>[0,4,8,12,16,20,24,28]</value></param>
<param><key>timeslot_nr</key><value>7</value></param>
</block>
<block>
<key>gsm_universal_ctrl_chans_demapper</key>
<param><key>id</key><value>gsm_universal_ctrl_chans_demapper_0_0_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>channel_types</key><value>[SDCCH, SDCCH, SDCCH, SDCCH, SDCCH, SDCCH, SDCCH, SDCCH,SACCH,SACCH,SACCH,SACCH]</value></param>
<param><key>starts_fn_mod51</key><value>[0,4,8,12,16,20,24,28]</value></param>
<param><key>timeslot_nr</key><value>5</value></param>
</block>
<block>
<key>gsm_universal_ctrl_chans_demapper</key>
<param><key>id</key><value>gsm_universal_ctrl_chans_demapper_0_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>channel_types</key><value>[SDCCH, SDCCH, SDCCH, SDCCH, SDCCH, SDCCH, SDCCH, SDCCH,SACCH,SACCH,SACCH,SACCH]</value></param>
<param><key>starts_fn_mod51</key><value>[0,4,8,12,16,20,24,28]</value></param>
<param><key>timeslot_nr</key><value>3</value></param>
</block>
<block>
<key>gsm_universal_ctrl_chans_demapper</key>
<param><key>id</key><value>gsm_universal_ctrl_chans_demapper_0_0_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>channel_types</key><value>[SDCCH, SDCCH, SDCCH, SDCCH, SDCCH, SDCCH, SDCCH, SDCCH,SACCH,SACCH,SACCH,SACCH]</value></param>
<param><key>starts_fn_mod51</key><value>[0,4,8,12,16,20,24,28]</value></param>
<param><key>timeslot_nr</key><value>6</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>250e3</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>10e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>30</value></param>
<param><key>bw0</key><value>200000</value></param>
<param><key>freq0</key><value>fc</value></param>
<param><key>gain_mode0</key><value>True</value></param>
<param><key>if_gain0</key><value>30</value></param>
<param><key>gain0</key><value>30</value></param>
<param><key>args</key><value>bladerf=0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ppm</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>ppm</value></param>
<param><key>short_id</key><value>p</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>gsm_clock_offset_control_0</source_block_id><sink_block_id>gsm_input_0</sink_block_id><source_key>ppm</source_key><sink_key>ppm_in</sink_key></connection>
<connection><source_block_id>gsm_control_channels_decoder_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>msgs</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>gsm_control_channels_decoder_0_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>msgs</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>gsm_control_channels_decoder_0_0_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>msgs</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>gsm_control_channels_decoder_0_0_0_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>msgs</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>gsm_control_channels_decoder_0_0_0_0_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>msgs</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>gsm_control_channels_decoder_0_0_0_1</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>msgs</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>gsm_control_channels_decoder_0_0_1</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>msgs</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>gsm_control_channels_decoder_0_0_1_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>msgs</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>gsm_decryption_0</source_block_id><sink_block_id>gsm_control_channels_decoder_0_0</sink_block_id><source_key>bursts</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_decryption_0_0</source_block_id><sink_block_id>gsm_control_channels_decoder_0_0_0</sink_block_id><source_key>bursts</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_decryption_0_0_0</source_block_id><sink_block_id>gsm_control_channels_decoder_0_0_0_0</sink_block_id><source_key>bursts</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_decryption_0_0_0_0</source_block_id><sink_block_id>gsm_control_channels_decoder_0_0_0_0_0</sink_block_id><source_key>bursts</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_decryption_0_0_1</source_block_id><sink_block_id>gsm_control_channels_decoder_0_0_0_1</sink_block_id><source_key>bursts</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_decryption_0_1</source_block_id><sink_block_id>gsm_control_channels_decoder_0_0_1</sink_block_id><source_key>bursts</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_decryption_0_1_0</source_block_id><sink_block_id>gsm_control_channels_decoder_0_0_1_0</sink_block_id><source_key>bursts</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_input_0</source_block_id><sink_block_id>gsm_receiver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gsm_receiver_0</source_block_id><sink_block_id>gsm_universal_ctrl_chans_demapper_0</sink_block_id><source_key>C0</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_receiver_0</source_block_id><sink_block_id>gsm_universal_ctrl_chans_demapper_0_0</sink_block_id><source_key>C0</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_receiver_0</source_block_id><sink_block_id>gsm_universal_ctrl_chans_demapper_0_0_0</sink_block_id><source_key>C0</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_receiver_0</source_block_id><sink_block_id>gsm_universal_ctrl_chans_demapper_0_0_0_0</sink_block_id><source_key>C0</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_receiver_0</source_block_id><sink_block_id>gsm_universal_ctrl_chans_demapper_0_0_0_0_0</sink_block_id><source_key>C0</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_receiver_0</source_block_id><sink_block_id>gsm_universal_ctrl_chans_demapper_0_0_0_1</sink_block_id><source_key>C0</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_receiver_0</source_block_id><sink_block_id>gsm_universal_ctrl_chans_demapper_0_0_1</sink_block_id><source_key>C0</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_receiver_0</source_block_id><sink_block_id>gsm_universal_ctrl_chans_demapper_0_0_1_0</sink_block_id><source_key>C0</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_receiver_0</source_block_id><sink_block_id>gsm_clock_offset_control_0</sink_block_id><source_key>measurements</source_key><sink_key>measurements</sink_key></connection>
<connection><source_block_id>gsm_universal_ctrl_chans_demapper_0</source_block_id><sink_block_id>gsm_control_channels_decoder_0</sink_block_id><source_key>bursts</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_universal_ctrl_chans_demapper_0_0</source_block_id><sink_block_id>gsm_decryption_0</sink_block_id><source_key>bursts</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_universal_ctrl_chans_demapper_0_0_0</source_block_id><sink_block_id>gsm_decryption_0_0</sink_block_id><source_key>bursts</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_universal_ctrl_chans_demapper_0_0_0_0</source_block_id><sink_block_id>gsm_decryption_0_0_0</sink_block_id><source_key>bursts</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_universal_ctrl_chans_demapper_0_0_0_0_0</source_block_id><sink_block_id>gsm_decryption_0_0_0_0</sink_block_id><source_key>bursts</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_universal_ctrl_chans_demapper_0_0_0_1</source_block_id><sink_block_id>gsm_decryption_0_0_1</sink_block_id><source_key>bursts</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_universal_ctrl_chans_demapper_0_0_1</source_block_id><sink_block_id>gsm_decryption_0_1</sink_block_id><source_key>bursts</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_universal_ctrl_chans_demapper_0_0_1_0</source_block_id><sink_block_id>gsm_decryption_0_1_0</sink_block_id><source_key>bursts</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>gsm_input_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>gsm_input_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
